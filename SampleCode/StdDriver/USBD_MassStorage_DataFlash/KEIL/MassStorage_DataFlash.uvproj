# Keil uVision project MassStorage_DataFlash.uvproj, settings and files
target MassStorage_DataFlash (ARM-ADS)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: MassStorage_DataFlash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1
  c include: .\;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group Source files
    ../: descriptors.c main.c MassStorage.c DataFlashProg.c
  group Library files
    ../../../../Library/StdDriver/src/: retarget.c usbd.c fmc.c clk.c sys.c
