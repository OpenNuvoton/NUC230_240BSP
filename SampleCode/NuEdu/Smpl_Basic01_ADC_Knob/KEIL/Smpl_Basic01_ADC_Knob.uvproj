# Keil uVision project Smpl_Basic01_ADC_Knob.uvproj, settings and files
target Smpl_Basic01_ADC_Knob (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_Basic01_ADC_Knob
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\NuEdu\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group Libraries
    ../../../../Library/StdDriver/src/: clk.c sys.c gpio.c adc.c uart.c
  group Common
    ../../../../Library/StdDriver/src/: retarget.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
  group User
    ../: main.c
  group NuEdu
    ../../../../Library/NuEdu/src/: NuEdu-Basic01_System.c NuEdu-Basic01_ADC_Knob.c
