# Keil uVision project ISP_UART.uvproj, settings and files
target ISP_UART (6160000::V6.16::ARMCLANG)
  device: NUC240VE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC230_240_ISP_UART0_PB0_PB1
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\Device\Nuvoton\NUC230_240\Include;..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC230_240.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/: system_NUC230_240.c
    ../../../../Library/Device/Nuvoton/NUC230_240/Source/ARM/: startup_NUC230_240.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c uart_transfer.c
